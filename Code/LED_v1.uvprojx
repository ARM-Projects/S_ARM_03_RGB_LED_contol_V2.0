# Keil uVision project LED_v1.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: TM4C123GH6PM Texas Instruments
  pack: Keil.TM4C_DFP.1.1.0
  cpu: IRAM(0x20000000,0x008000) IROM(0x00000000,0x040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: LED_v1
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Source_files
    ./MCAL/DIO/: DIO_prog.c
    ./: main.c
    ./HAL/LED/: LED.c
    ./HAL/BUTTON/: Button.c
    ./APP/: APP.c
  group Header_files
    ./MCAL/DIO/: DIO_interface.h DIO_config.h DIO_private.h
    ./STD_LIBRARIES/: bit_math.h STD_TYPES.h
    ./HAL/LED/: LED.h
    ./HAL/BUTTON/: Button.h
    ./APP/: APP.h
software components: CMSIS:CORE 5.3.0, Device:Startup 1.0.1
